# IAR project Backup of GTD-5x00(F)N_Cartridge.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM355 AnalogDevices ADUCM355
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: Application/Info; Application/Measuring; Application/Measuring/List; Application/Measuring/Sensing_Process; Application/Modbus; Base; Drivers/AD_Library; Drivers/BSP/HS300x; Drivers/BSP/LED; Drivers/Internal_Peripheral/ADC; Drivers/Internal_Peripheral/DAC; Drivers/Internal_Peripheral/FLASH; Drivers/Internal_Peripheral/GPT; Drivers/Internal_Peripheral/I2C; Drivers/Internal_Peripheral/TIA; Drivers/Internal_Peripheral/UART; Drivers/Internal_Peripheral/WDT
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GTD-5x00(F)N_Cartridge_REV.bin
  ILINK.IlinkOutputFile: GTD-5x00(F)N_Cartridge.out
  ILINK.IlinkIcfFile: Base\ADuCM355.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application/Info
    Application/Info/: option.c option.h version.c version.h
  group Application/Measuring
    Application/Measuring/: measuring.c measuring.h
  group Application/Measuring/List
    Application/Measuring/List/: sensor_list.h
  group Application/Measuring/Sensing_Process
    Application/Measuring/Sensing_Process/: sensing_process.c sensing_process.h
  group Application/Modbus
    Application/Modbus/: crc16.c crc16.h modbus.c modbus.h modbus_map.c modbus_map.h modbus_rtu_slave.c modbus_rtu_slave.h
  group Base
    Base/: ADuCM355.icf ADuCM355_Peri.h common.h main.c main.h startup_ADuCM355.c system_ADuCM355.c
  group Driver/AD_Library
    Drivers/AD_Library/: AfeAdcLib.c AfeAdcLib.h AfeDacLib.c AfeDacLib.h AfeTiaLib.c AfeTiaLib.h AfeWdtLib.c AfeWdtLib.h ClkLib.c ClkLib.h DioLib.c DioLib.h DmaLib.c DmaLib.h FeeLib.c FeeLib.h GptLib.c GptLib.h I2cLib.c I2cLib.h PwrLib.c PwrLib.h RstLib.c RstLib.h UrtLib.c UrtLib.h
  group Driver/BSP/HS300x
    Drivers/BSP/HS300x/: hs300x.c hs300x.h
  group Driver/BSP/LED
    Drivers/BSP/LED/: led.c led.h
  group Driver/Internal_Peripheral/ADC
    Drivers/Internal_Peripheral/ADC/: adc.c adc.h
  group Driver/Internal_Peripheral/DAC
    Drivers/Internal_Peripheral/DAC/: dac.c dac.h
  group Driver/Internal_Peripheral/FLASH
    Drivers/Internal_Peripheral/FLASH/: flash.c flash.h
  group Driver/Internal_Peripheral/GPT
    Drivers/Internal_Peripheral/GPT/: gpt.c gpt.h
  group Driver/Internal_Peripheral/I2C
    Drivers/Internal_Peripheral/I2C/: i2c.c i2c.h
  group Driver/Internal_Peripheral/TIA
    Drivers/Internal_Peripheral/TIA/: tia.c tia.h
  group Driver/Internal_Peripheral/UART
    Drivers/Internal_Peripheral/UART/: uart.c uart.h
  group Driver/Internal_Peripheral/WDT
    Drivers/Internal_Peripheral/WDT/: wdt.c wdt.h
