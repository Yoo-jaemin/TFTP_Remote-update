<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GTD-5x00(F)N_Cartridge.ewp</path>
  </project>
  <batchBuild/>
</workspace>


