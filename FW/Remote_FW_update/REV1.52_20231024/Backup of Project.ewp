# IAR project Backup of Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: Application; Application/Configuration; Application/External_Interface; Application/IR_Sensing; Application/System_Option; Base; Drivers/BSP/ADC; Drivers/BSP/Digital_Potentiometer; Drivers/BSP/EEPROM; Drivers/BSP/LED; Drivers/BSP/Temperature_Sensor; Drivers/Internal_Peripheral/ADC; Drivers/Internal_Peripheral/DMA; Drivers/Internal_Peripheral/GPIO; Drivers/Internal_Peripheral/I2C; Drivers/Internal_Peripheral/I2C/I2C1_DPM; Drivers/Internal_Peripheral/I2C/I2C2_EEPROM; Drivers/Internal_Peripheral/SPI; Drivers/Internal_Peripheral/TIMER; Drivers/Internal_Peripheral/USART; Drivers/Internal_Peripheral/IWDG; Drivers/STM32F1xx_HAL_Driver/Inc; Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; Drivers/CMSIS/Device/ST/STM32F1xx/Include; Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GSA-970_REV.bin
  ILINK.IlinkOutputFile: GSA-970.out
  ILINK.IlinkIcfFile: Base\stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    Application/: version.h
  group Application/Configuration
    Application/External_Interface/: eeprom.c eeprom.h eeprom_limit_table.h
  group Application/External_Interface
    Application/External_Interface/: crc16.c crc16.h modbus.c modbus.h
  group Application/IR_Sensing
    Application/IR_Sensing/: ir.c ir.h warmup.c warmup.h
  group Application/System_Option
    Application/System_Option/: option.c option.h
  group Base
    Base/: btimer.c btimer.h common.h main.c main.h startup_stm32f103xe.s stm32f1xx_hal_conf.h stm32f1xx_hal_msp.c stm32f1xx_it.c stm32f1xx_it.h
  group Drivers/BSP/ADC
    Drivers/BSP/ADC/: ads868x.c ads868x.h
  group Drivers/BSP/Digital_Potentiometer
    Drivers/BSP/Digital_Potentiometer/: tpl0102.c tpl0102.h
  group Drivers/BSP/EEPROM
    Drivers/BSP/EEPROM/: at24c32.c at24c32.h
  group Drivers/BSP/LED
    Drivers/BSP/LED/: led.c led.h
  group Drivers/BSP/Temperature_Sensor
    Drivers/BSP/Temperature_Sensor/: lmt84.c lmt84.h
  group Drivers/CMSIS
    Drivers/CMSIS/: system_stm32f1xx.c
  group Drivers/Internal_Peripheral/ADC
    Drivers/Internal_Peripheral/ADC/: adc.c adc.h
  group Drivers/Internal_Peripheral/I2C
    Drivers/Internal_Peripheral/I2C/: i2c.c i2c.h
  group Drivers/Internal_Peripheral/I2C/I2C1_DPM
    Drivers/Internal_Peripheral/I2C/I2C1_DPM/: i2c1.c i2c1.h
  group Drivers/Internal_Peripheral/I2C/I2C2_EEPROM
    Drivers/Internal_Peripheral/I2C/I2C2_EEPROM/: i2c2.c i2c2.h
  group Drivers/Internal_Peripheral/IWDG
    Drivers/Internal_Peripheral/IWDG/: iwdg.c iwdg.h
  group Drivers/Internal_Peripheral/SPI
    Drivers/Internal_Peripheral/SPI/: spi.c spi.h
  group Drivers/Internal_Peripheral/TIMER
    Drivers/Internal_Peripheral/TIMER/: tim1.c tim1.h
  group Drivers/Internal_Peripheral/USART
    Drivers/Internal_Peripheral/USART/: usart3.c usart3.h usart5.c usart5.h
  group Drivers/STM32F1xx_HAL_Driver/Inc
    Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal.h stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h stm32f1xx_hal_cortex.h stm32f1xx_hal_dma.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_i2c.h stm32f1xx_hal_iwdg.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_spi.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h
  group Drivers/STM32F1xx_HAL_Driver/Src
    Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
