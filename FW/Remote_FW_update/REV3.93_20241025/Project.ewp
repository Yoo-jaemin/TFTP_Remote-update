# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: Application; Application/Data_Logging; Application/Flow_Control; Application/Info; Application/Interface/Industrial_Standard/mA_Output; Application/Interface/Industrial_Standard/PoE; Application/Interface/Industrial_Standard/RS-485; Application/Interface/Protocol; Application/Interface/Relay; Application/Interface/Sensor_Module; Application/Measuring; Application/Measuring/List; Application/Measuring/Sensing_Process; Application/Measuring/Sensing_Process/Gas; Application/Measuring/Sensing_Process/Power_Supply; Application/Measuring/Sensing_Process/Pressure; Application/Measuring/Sensing_Process/Temperature; Application/Power_Control; Application/Storage; Application/Storage/EEPROM; Application/Storage/NAND; Application/Storage/uSD; Application/System_Mode; Application/System_Mode/AllBase; Application/System_Mode/Boot; Application/System_Mode/Function; Application/System_Mode/Function/Item/; Application/System_Mode/Function/Item/Func_Factory; Application/System_Mode/Function/Item/Func_FlowSet; Application/System_Mode/Function/Item/Func_Interface; Application/System_Mode/Function/Item/Func_Measuring; Application/System_Mode/Function/Item/Func_System; Application/System_Mode/Function/Item/Func_Test; Application/System_Mode/Normal; Application/System_Mode/Password; Application/System_Mode/Self_Test; Application/Task; Application/View; Application/View/vAllBase; Application/View/vBoot; Application/View/vFunction; Application/View/vFunction/Item/vFunc_Factory; Application/View/vFunction/Item/vFunc_FlowSet; Application/View/vFunction/Item/vFunc_Interface; Application/View/vFunction/Item/vFunc_Measuring; Application/View/vFunction/Item/vFunc_System; Application/View/vFunction/Item/vFunc_Test; Application/View/vImage; Application/View/vImage/Item; Application/View/vLibrary; Application/View/vMeasuring; Application/View/vPassword; Application/View/vPowerOff; Application/View/vSelf_Test; Application/View/vStatusBar; Base; Drivers/BSP/Battery_Charger; Drivers/BSP/Buzzer; Drivers/BSP/DAC; Drivers/BSP/Digital_Potentiometer; Drivers/BSP/EEPROM; Drivers/BSP/KEY; Drivers/BSP/LCD; Drivers/BSP/LCD/LCD_Driver; Drivers/BSP/LED; Drivers/BSP/Pump; Drivers/BSP/SD; Drivers/BSP/Temperature_Sensor; Drivers/BSP/USB_PD_Controller; Drivers/Internal_Peripheral/ADC; Drivers/Internal_Peripheral/BOR; Drivers/Internal_Peripheral/FSMC; Drivers/Internal_Peripheral/I2C; Drivers/Internal_Peripheral/I2C/I2C1_EEPROM; Drivers/Internal_Peripheral/I2C/I2C2_mA_DAC_PsenDPM_USB_PD_Charger; Drivers/Internal_Peripheral/IWDG; Drivers/Internal_Peripheral/RTC; Drivers/Internal_Peripheral/TIM; Drivers/Internal_Peripheral/TIM/TIM3_Pump_Drive; Drivers/Internal_Peripheral/TIM/TIM4_LCD_Backlight; Drivers/Internal_Peripheral/TIM/TIM12_Piezo_Drive; Drivers/Internal_Peripheral/USART; Drivers/Internal_Peripheral/USART/USART1_DebugPrintf; Drivers/Internal_Peripheral/USART/USART3_SensorModule; Drivers/STM32F4xx_HAL_Driver/Inc; Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; Drivers/CMSIS/Device/ST/STM32F4xx/Include; Drivers/CMSIS/Include; Middlewares/FatFs; Middlewares/FatFs/Core; Middlewares/FatFs/Drivers; Middlewares/FatFs/Option; Middlewares/GDI; Middlewares/GDI/Fonts; Middlewares/GDI/Color; Middlewares/LwIP/src/include; Middlewares/LwIP/system
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GTD-5x00(F)N_REV.bin
  ILINK.IlinkOutputFile: GTD-5x00(F)N.out
  ILINK.IlinkIcfFile: Base\stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application/Data_Logging
    Application/Data_Logging/: data_log.c data_log.h
  group Application/Flow_Control
    Application/Flow_Control/: flow_control.c flow_control.h
  group Application/Info
    Application/Info/: New_Gas_Addition_Manual.txt option.c option.h version.c version.h
  group Application/Interface/Industrial_Standard/mA_Output
    Application/Interface/Industrial_Standard/mA_Output/: ma_output.c ma_output.h
  group Application/Interface/Industrial_Standard/PoE
    Application/Interface/Industrial_Standard/PoE/: app_ethernet.c app_ethernet.h ethernetif.c ethernetif.h fsdata_custom.c httpd_cgi_ssi.c httpd_cgi_ssi.h httpd_parsing.c httpd_parsing.h lwipopts.h poe.c poe.h tcp_echoserver.c tcp_echoserver.h tftp.c tftp_client.h tftp_common.h tftp_example.c tftp_example.h tftp_opts.h
  group Application/Interface/Industrial_Standard/RS-485
    Application/Interface/Industrial_Standard/RS-485/: rs485.c rs485.h
  group Application/Interface/Protocol
    Application/Interface/Protocol/: crc16.c crc16.h modbus_map.c modbus_map.h modbus_rtu_master.c modbus_rtu_master.h modbus_rtu_slave.c modbus_rtu_slave.h modbus_tcp_slave.c modbus_tcp_slave.h
  group Application/Interface/Relay
    Application/Interface/Relay/: relay.c relay.h
  group Application/Interface/Sensor_Module
    Application/Interface/Sensor_Module/: cartridge.c cartridge.h cavity.c cavity.h sensor_eep_map.c sensor_eep_map.h
  group Application/Measuring
    Application/Measuring/: measuring.c measuring.h
  group Application/Measuring/List
    Application/Measuring/List/: ct_gas_list.h ir_gas_list.h model_list.h sensor_list.h
  group Application/Measuring/Sensing_Process
    Application/Measuring/Sensing_Process/: sensing_process.c sensing_process.h
  group Application/Measuring/Sensing_Process/Gas
    Application/Measuring/Sensing_Process/Gas/: ct.c ct.h ir.c ir.h
  group Application/Measuring/Sensing_Process/Power_Supply
    Application/Measuring/Sensing_Process/Power_Supply/: power_supply.c power_supply.h
  group Application/Measuring/Sensing_Process/Pressure
    Application/Measuring/Sensing_Process/Pressure/: pressure.c pressure.h
  group Application/Measuring/Sensing_Process/Temperature
    Application/Measuring/Sensing_Process/Temperature/: temperature.c temperature.h
  group Application/Power_Control
    Application/Power_Control/: power_control.c power_control.h
  group Application/Storage/EEPROM
    Application/Storage/EEPROM/: eeprom.c eeprom.h
  group Application/Storage/NAND
    Application/Storage/NAND/: nand_flash.c nand_flash.h
  group Application/Storage/uSD
    Application/Storage/uSD/: micro_sd.c micro_sd.h
  group Application/System_Mode/AllBase
    Application/System_Mode/AllBase/: allbase_mode.c allbase_mode.h
  group Application/System_Mode/Boot
    Application/System_Mode/Boot/: system_conf.c system_conf.h system_init.c system_init.h
  group Application/System_Mode/Function
    Application/System_Mode/Function/: function_mode.c function_mode.h
  group Application/System_Mode/Function/Item/Func_Factory
    Application/System_Mode/Function/Item/Func_Factory/: func_factory.c func_factory.h
  group Application/System_Mode/Function/Item/Func_FlowSet
    Application/System_Mode/Function/Item/Func_FlowSet/: func_flowset.c func_flowset.h
  group Application/System_Mode/Function/Item/Func_Interface
    Application/System_Mode/Function/Item/Func_Interface/: func_interface.c func_interface.h
  group Application/System_Mode/Function/Item/Func_Measuring
    Application/System_Mode/Function/Item/Func_Measuring/: func_measuring.c func_measuring.h
  group Application/System_Mode/Function/Item/Func_System
    Application/System_Mode/Function/Item/Func_System/: func_system.c func_system.h
  group Application/System_Mode/Function/Item/Func_Test
    Application/System_Mode/Function/Item/Func_Test/: func_test.c func_test.h
  group Application/System_Mode/Normal
    Application/System_Mode/Normal/: normal_mode.c normal_mode.h
  group Application/System_Mode/Password
    Application/System_Mode/Password/: password_mode.c password_mode.h
  group Application/System_Mode/Self_Test
    Application/System_Mode/Self_Test/: self_test.c self_test.h
  group Application/Task
    Application/Task/: task.c task.h task_sync_timer.c task_sync_timer.h
  group Application/View/vAllBase
    Application/View/vAllBase/: vallbase_mode.c vallbase_mode.h
  group Application/View/vBoot
    Application/View/vBoot/: vboot.c vboot.h
  group Application/View/vFunction
    Application/View/vFunction/: vfunction_mode.c vfunction_mode.h
  group Application/View/vFunction/Item/vFunc_Factory
    Application/View/vFunction/Item/vFunc_Factory/: vfunc_factory.c vfunc_factory.h
  group Application/View/vFunction/Item/vFunc_FlowSet
    Application/View/vFunction/Item/vFunc_FlowSet/: vfunc_flowset.c vfunc_flowset.h
  group Application/View/vFunction/Item/vFunc_Interface
    Application/View/vFunction/Item/vFunc_Interface/: vfunc_interface.c vfunc_interface.h
  group Application/View/vFunction/Item/vFunc_Measuring
    Application/View/vFunction/Item/vFunc_Measuring/: vfunc_measuring.c vfunc_measuring.h
  group Application/View/vFunction/Item/vFunc_System
    Application/View/vFunction/Item/vFunc_System/: vfunc_system.c vfunc_system.h
  group Application/View/vFunction/Item/vFunc_Test
    Application/View/vFunction/Item/vFunc_Test/: vfunc_test.c vfunc_test.h
  group Application/View/vImage
    Application/View/vImage/: vimage.c vimage.h
  group Application/View/vImage/Item
    Application/View/vImage/Item/: vimage_bat.h vimage_com.h vimage_disk.h vimage_intro.h vimage_pump.h vimage_status.h
  group Application/View/vLibrary
    Application/View/vLibrary/: vlibrary.c vlibrary.h
  group Application/View/vMeasuring
    Application/View/vMeasuring/: vmeasuring.c vmeasuring.h
  group Application/View/vPassword
    Application/View/vPassword/: vpassword_mode.c vpassword_mode.h
  group Application/View/vPowerOff
    Application/View/vPowerOff/: vpower_off.c vpower_off.h
  group Application/View/vSelf_Test
    Application/View/vSelf_Test/: vself_test.c vself_test.h
  group Application/View/vStatusBar
    Application/View/vStatusBar/: vstatusbar.c vstatusbar.h
  group Base
    Base/: btimer.c btimer.h common.h main.c main.h startup_stm32f407xx.s stm32f4xx_hal_conf.h stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_it.h usage.suc
  group Drivers/BSP/Battery_Charger
    Drivers/BSP/Battery_Charger/: bq2579x.c bq2579x.h
  group Drivers/BSP/Buzzer
    Drivers/BSP/Buzzer/: buzzer.c buzzer.h
  group Drivers/BSP/DAC
    Drivers/BSP/DAC/: dac8571.c dac8571.h
  group Drivers/BSP/Digital_Potentiometer
    Drivers/BSP/Digital_Potentiometer/: mcp46x1.c mcp46x1.h
  group Drivers/BSP/EEPROM
    Drivers/BSP/EEPROM/: at24c32.c at24c32.h
  group Drivers/BSP/KEY
    Drivers/BSP/KEY/: key.c key.h
  group Drivers/BSP/LCD
    Drivers/BSP/LCD/: lcd.c lcd.h
  group Drivers/BSP/LCD/LCD_Driver
    Drivers/BSP/LCD/LCD_Driver/: ili9225g.c ili9225g.h
  group Drivers/BSP/LED
    Drivers/BSP/LED/: led.c led.h
  group Drivers/BSP/Pump
    Drivers/BSP/Pump/: pump.c pump.h
  group Drivers/BSP/SD
    Drivers/BSP/SD/: bsp_sd.c bsp_sd.h
  group Drivers/BSP/Temperature_Sensor
    Drivers/BSP/Temperature_Sensor/: lmt84.c lmt84.h
  group Drivers/BSP/USB_PD_Controller
    Drivers/BSP/USB_PD_Controller/: tps25750.c tps25750.h tps25750_config.h
  group Drivers/CMSIS
    Base/: system_stm32f4xx.c
  group Drivers/Internal_Peripheral/ADC
    Drivers/Internal_Peripheral/ADC/: adc.c adc.h
  group Drivers/Internal_Peripheral/BOR
    Drivers/Internal_Peripheral/BOR/: bor.c bor.h
  group Drivers/Internal_Peripheral/FSMC
    Drivers/Internal_Peripheral/FSMC/: fsmc.c fsmc.h
  group Drivers/Internal_Peripheral/I2C
    Drivers/Internal_Peripheral/I2C/: i2c.c i2c.h
  group Drivers/Internal_Peripheral/I2C/I2C1_EEPROM
    Drivers/Internal_Peripheral/I2C/I2C1_EEPROM/: i2c1.c i2c1.h
  group Drivers/Internal_Peripheral/I2C/I2C2_mA_DAC_PsenDPM_USB_PD_Charger
    Drivers/Internal_Peripheral/I2C/I2C2_mA_DAC_PsenDPM_USB_PD_Charger/: i2c2.c i2c2.h
  group Drivers/Internal_Peripheral/IWDG
    Drivers/Internal_Peripheral/IWDG/: iwdg.c iwdg.h
  group Drivers/Internal_Peripheral/RTC
    Drivers/Internal_Peripheral/RTC/: rtc.c rtc.h
  group Drivers/Internal_Peripheral/TIM
    Drivers/Internal_Peripheral/TIM/: tim.c tim.h
  group Drivers/Internal_Peripheral/TIM/TIM12_Piezo_Drive
    Drivers/Internal_Peripheral/TIM/TIM12_Piezo_Drive/: tim12.c tim12.h
  group Drivers/Internal_Peripheral/TIM/TIM3_Pump_Drive
    Drivers/Internal_Peripheral/TIM/TIM3_Pump_Drive/: tim3.c tim3.h
  group Drivers/Internal_Peripheral/TIM/TIM4_LCD_Backlight
    Drivers/Internal_Peripheral/TIM/TIM4_LCD_Backlight/: tim4.c tim4.h
  group Drivers/Internal_Peripheral/USART
    Drivers/Internal_Peripheral/USART/: usart.c usart.h
  group Drivers/Internal_Peripheral/USART/USART1_DebugPrintf
    Drivers/Internal_Peripheral/USART/USART1_DebugPrintf/: usart1.c usart1.h
  group Drivers/Internal_Peripheral/USART/USART3_SensorModule
    Drivers/Internal_Peripheral/USART/USART3_SensorModule/: usart3.c usart3.h
  group Drivers/STM32F4xx_HAL_Driver/Inc
    Drivers/STM32F4xx_HAL_Driver/Inc/: stm32_assert_template.h stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_dma.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_i2c.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_nand.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_i2c.h stm32f4xx_ll_sdmmc.h
  group Drivers/STM32F4xx_HAL_Driver/Src
    Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_nand.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_i2c.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FatFs/Core
    Middlewares/FatFs/Core/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h ffconf_template.h integer.h
  group Middlewares/FatFs/Drivers
    Middlewares/FatFs/Drivers/: sd_diskio.c sd_diskio.h
  group Middlewares/FatFs/Option
    Middlewares/FatFs/Option/: syscall.c unicode.c
  group Middlewares/GDI
    Middlewares/GDI/: gdi.c gdi.h
  group Middlewares/GDI/Color
    Middlewares/GDI/Color/: color.h rgb_table_16bit.h
  group Middlewares/GDI/Fonts
    Middlewares/GDI/Fonts/: fimg07x12.h font05x08.h font07x12.h font11x16.h font29x46.h fonts.c fonts.h
  group Middlewares/LwIP/Api
    Middlewares/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/apps/httpd
    Middlewares/LwIP/src/apps/httpd/: fs.c httpd.c
  group Middlewares/LwIP/Core
    Middlewares/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/LwIP/Core/IPv4
    Middlewares/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/LwIP/Netif
    Middlewares/LwIP/src/netif/: ethernet.c
