# IAR project SD_BootLoader_MX.ewp, settings and files
configuration GTD_5100FN_BootLoader (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: Base; Drivers\CMSIS\Include; Drivers\CMSIS\Device\ST\STM32F4xx\Include; Drivers\STM32F4xx_HAL_Driver\Inc; Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; App\SD; Drivers\FSMC; Drivers\GPIO; Drivers\LCD; Drivers\LCD\LCD_Driver; Drivers\SD; Drivers\TIMER; Middlewares\FatFs; Middlewares\FatFs\src; Middlewares\FatFs\src\option; Middlewares\GDI; Middlewares\GDI\Color; Middlewares\GDI\Fonts; Drivers\USART; App\Flash; App\Task; App\IO_Ctrl; App\Display; App\Sensor_Upload; App\Nand; App\Protocol
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GTD-5100FN_BIOS_REV.bin
  ILINK.IlinkOutputFile: SD_BootLoader_MX.out
  ILINK.IlinkIcfFile: Base\stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App/Display
    App/Display/: Display.c Display.h
  group App/Flash
    App/Flash/: Flash.c Flash.h
  group App/IO_Ctrl
    App/IO_Ctrl/: IO_Ctrl.c IO_Ctrl.h
  group App/Nand
    App/Nand/: nand_flash.c nand_flash.h
  group App/Protocol
    App/Protocol/: crc16.c crc16.h modbus_rtu_master.c modbus_rtu_master.h
  group App/SD
    App/SD/: SD_Card.c SD_Card.h
  group App/Sensor_Upload
    App/Sensor_Upload/: CRC.c CRC.h Sensor_Upload.c Sensor_Upload.h
  group App/Task
    App/Task/: Task.c Task.h
  group Base
    Base/: common.h main.c main.h startup_stm32f407xx.s stm32f4xx_hal_conf.h stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_it.h
  group Drivers/CMSIS
    Base/: system_stm32f4xx.c
  group Drivers/FSMC
    Drivers/FSMC/: fsmc.c fsmc.h
  group Drivers/GPIO
    Drivers/GPIO/: gpio.c gpio.h
  group Drivers/LCD
    Drivers/LCD/: lcd.c lcd.h
  group Drivers/LCD/LCD_Driver
    Drivers/LCD/LCD_Driver/: ili9225g.c ili9225g.h
  group Drivers/SD
    Drivers/SD/: bsp_driver_sd.c bsp_driver_sd.h sd_diskio.c sd_diskio.h
  group Drivers/STM32F4xx_HAL_Driver
    Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_nand.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c
  group Drivers/USART
    Drivers/USART/: usart.c usart.h
  group Middlewares/FatFs
    Middlewares/FatFs/src/: diskio.c diskio.h fatfs.c fatfs.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h ffconf.h ffconf_template.h integer.h
  group Middlewares/GDI
    Middlewares/GDI/: gdi.c gdi.h
  group Middlewares/GDI/Fonts
    Middlewares/GDI/Fonts/: fimg07x12.h font07x12.h font07x28.h font11x16.h font29x48.h font32x53.h fonts.c fonts.h
